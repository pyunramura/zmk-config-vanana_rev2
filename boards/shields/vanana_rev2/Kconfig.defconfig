## boards/shields/vanana_rev2/Kconfig.defconfig
```kconfig
if SHIELD_VANANA_REV2

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Vanana"

endif
```
